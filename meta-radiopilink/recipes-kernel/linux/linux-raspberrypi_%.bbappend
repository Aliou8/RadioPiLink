FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://kernelconfig.cfg"
